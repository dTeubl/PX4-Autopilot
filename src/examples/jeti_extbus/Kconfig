## src/examples/jeti_extbus/Kconfig
```kconfig
menuconfig EXAMPLES_JETI_EXTBUS
	bool "jeti_extbus"
	default y
	---help---
		Enable support for JETI EXT BUS app
```
